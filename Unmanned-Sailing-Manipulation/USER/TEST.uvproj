# Keil uVision project TEST.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TEST +hex
  c flags: Optim=1
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\WDG;..\HARDWARE\TIMER;..\HARDWARE\LCD;..\USMART;..\HARDWARE\USART2;..\HARDWARE\GPS;..\HARDWARE\AHRS;..\HARDWARE\HC05;..\FAT;..\HARDWARE\SD;..\HARDWARE\SPI;..\HARDWARE\Gprs;..\HARDWARE\ADC;..\HARDWARE\USART3;..\HARDWARE\LCD12864;..\HARDWARE\24CXX
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: STM32F10x.s
  group USER
    ../USMART/: readme.txt
    ./: test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/LCD/: ILI93xx.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/GPS/: gps.c
    ../HARDWARE/AHRS/: AHRS.c
    ../HARDWARE/HC05/: hc05.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/SD/: MMC_SD.C
    ../HARDWARE/Gprs/: gprs.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/LCD12864/: LCD12864.c
    ../HARDWARE/24CXX/: 24cxx.c myiic.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group FAT
    ../FAT/: diskio.c ff.c
